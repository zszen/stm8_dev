# IAR project test3.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8S_Std\inc\; STM8S_Std\src\; Zszen_Std\; user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test3.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: STM8S_Std\inc; STM8S_Std\src; Zszen_Std
  OBJCOPY.OOCOutputFile: test3.srec
  ILINK.IlinkOutputFile: test3.out
  group STM8S_Std
    STM8S_Std/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_itc.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group user
    ./: main.c
  group user/test
    test/: test_adc.c test_awu.c test_gpio.c test_ir501.c test_ledfade.c test_lightingOnWithoutTouch.c test_tim.c test_urat.c
  group Zszen_Std
    Zszen_Std/: ZDebug.c ZTime.c
