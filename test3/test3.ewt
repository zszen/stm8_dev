<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>STM8S_Std</name>
    <file>
      <name>$PROJ_DIR$\STM8S_Std\src\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_Std\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_Std\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_Std\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_Std\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_Std\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_Std\src\stm8s_uart1.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <group>
      <name>test</name>
      <file>
        <name>$PROJ_DIR$\test\test_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\test\test_awu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\test\test_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\test\test_ir501.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\test\test_ledfade.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\test\test_lightingOnWithoutTouch.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\test\test_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\test\test_urat.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
  </group>
  <group>
    <name>Zszen_Std</name>
    <file>
      <name>$PROJ_DIR$\Zszen_Std\ZDebug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Zszen_Std\ZTime.c</name>
    </file>
  </group>
</project>


