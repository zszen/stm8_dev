# IAR project FWLib.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCDiagSuppress: Pe117,Pe188,Pe550,Pe940,Pa082,Pa089
  ICCSTM8.CCIncludePath2: Libraries\STM8_TouchSensing_Driver\inc; Libraries\STM8S_StdPeriph_Driver\inc; Project\Discover\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: FWLib.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  group (top)
    Libraries/STM8_TouchSensing_Driver/src/: STM8_TSL_RC_API.c STM8_TSL_RC_IODriver.c STM8_TSL_RC_MultiChannelKey.c STM8_TSL_RC_Services.c STM8_TSL_RC_SingleChannelKey.c STM8_TSL_RC_TimerDriver.c
    Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
