# IAR project STM8S105C6-Board.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: Libraries\STM8_TouchSensing_Driver\inc; Libraries\STM8S_StdPeriph_Driver\inc; Project\Discover\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: STM8S105C6-Board.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    Debug/Exe/: FWLib.a
    Project/Discover/src/: main.c
